# Keil uVision project F103RET6.uvprojx, settings and files
target Project (6220000::V6.22::ARMCLANG)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: F103RET6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE,USER_VECT_TAB_ADDRESS
  c include: ..\CMSIS\Inc;..\CMSIS\Device\Inc;..\Drivers\STM32F1xx_HAL_Driver\Inc;..\Drivers\Peripherals\Inc;..\Middlewares\FreeRTOS\Inc;..\Middlewares\UsbCDC\Inc;..\Hardware\Inc;..\User\Core\Inc;..\User\Tasks\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ./: startup_stm32f103xe.s
  group CMSIS
    ../CMSIS/Device/Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Inc/: stm32f1xx_hal_conf.h
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_cec.c stm32f1xx_hal_cortex.c stm32f1xx_hal_crc.c stm32f1xx_hal_dac.c stm32f1xx_hal_dac_ex.c stm32f1xx_hal_dma.c stm32f1xx_hal_eth.c stm32f1xx_hal_exti.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_hcd.c stm32f1xx_hal_i2c.c stm32f1xx_hal_i2s.c stm32f1xx_hal_irda.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_mmc.c stm32f1xx_hal_nand.c stm32f1xx_hal_nor.c stm32f1xx_hal_pccard.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_hal_sd.c stm32f1xx_hal_smartcard.c stm32f1xx_hal_spi.c stm32f1xx_hal_sram.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c stm32f1xx_hal_wwdg.c stm32f1xx_ll_adc.c stm32f1xx_ll_crc.c stm32f1xx_ll_dac.c stm32f1xx_ll_dma.c stm32f1xx_ll_exti.c stm32f1xx_ll_fsmc.c stm32f1xx_ll_gpio.c stm32f1xx_ll_i2c.c stm32f1xx_ll_pwr.c stm32f1xx_ll_rcc.c stm32f1xx_ll_rtc.c stm32f1xx_ll_sdmmc.c stm32f1xx_ll_spi.c stm32f1xx_ll_tim.c stm32f1xx_ll_usart.c stm32f1xx_ll_usb.c stm32f1xx_ll_utils.c
  group Drivers/Peripherals
    ../Drivers/Peripherals/Src/: clock.c dma.c flash.c gpio.c sdio.c spi.c tim.c uart.c usb.c
  group Middlewares/FreeRTOS
    ../Middlewares/FreeRTOS/Inc/: FreeRTOSConfig.h
    ../Middlewares/FreeRTOS/Src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../Middlewares/FreeRTOS/Port/: heap_4.c port.c
  group Middlewares/UsbCDC
    ../Middlewares/UsbCDC/Src/: usbd_cdc.c usbd_conf.c usbd_core.c usbd_ctlreq.c usbd_desc.c usbd_ioreq.c
  group User/Core
    ../User/Core/Inc/: config.h
    ../User/Core/Src/: main.c stm32f1xx_hal_msp.c stm32f1xx_it.c
  group Uaer/Tasks
    ../User/Tasks/Src/: task_log.c task_test.c
