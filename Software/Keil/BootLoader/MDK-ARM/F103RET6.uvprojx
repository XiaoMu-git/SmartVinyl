# Keil uVision project F103RET6.uvprojx, settings and files
target Project (6140000::V6.14::ARMCLANG)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: F103RET6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE,USER_VECT_TAB_ADDRESS
  c include: ..\CMSIS\Inc;..\CMSIS\Device\Inc;..\Drivers\STM32F1xx_HAL_Driver\Inc;..\Drivers\Peripherals\Inc;..\User\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ./: startup_stm32f103xe.s
  group CMSIS
    ../CMSIS/Device/Src/: system_stm32f1xx.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Inc/: stm32f1xx_hal_conf.h
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal_usart.c
  group Drivers/Peripherals
    ../Drivers/Peripherals/Src/: clock.c flash.c gpio.c uart.c
  group User
    ../User/Inc/: config.h
    ../User/Src/: stm32f1xx_hal_msp.c stm32f1xx_it.c main.c
